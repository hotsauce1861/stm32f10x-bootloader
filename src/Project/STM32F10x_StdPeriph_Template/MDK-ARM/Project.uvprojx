# Keil uVision project Project.uvprojx, settings and files
target STM32F1X-BOOTLOADER (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM3210B-EVAL +hex
  AfterMake: Z:\work\pmsm_pretest\bootloader\Scripts\create_bin.bat
  AfterMake: Z:\work\pmsm_pretest\bootloader\Scripts\copy_firmware.bat
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Iap;..\..\..\User;..\..\..\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x2fff
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../../../User/: main.c stm32f10x_it.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_exti.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_tim.c
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../User/: system_stm32f10x.c
  group MDK-ARM
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s startup_stm32f10x_hd_vl.s
  group Doc
    ./: readme.txt
  group Iap
    ../../../Iap/: common.c download.c upload.c ymodem.c
  group Driver
    ../../../Driver/: usart.c sys_timer.c
software components: CMSIS:CORE 5.1.2
